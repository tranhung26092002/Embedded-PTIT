# Keil uVision project Blink_Led.uvprojx, settings and files
target Blink (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CDUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink_Led +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F401xx
  c include: ..\Lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\Lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\Lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Lib\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Project\STM32F4xx_StdPeriph_Templates
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Lib
    ../Lib/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_exti.c
  group User
    ../Lib/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Project/STM32F4xx_StdPeriph_Templates/: stm32f4xx_it.c system_stm32f4xx.c main.c
software components: CMSIS:CORE 4.3.0, Device:STM32Cube LL:Common 1.8.1, Device:STM32Cube LL:GPIO 1.8.1, Device:STM32Cube LL:PWR 1.8.1, Device:STM32Cube LL:RCC 1.8.1, Device:STM32Cube LL:UTILS 1.8.1, Device:Startup 2.6.3
